#include "frag.h"
#include <string.h>

static const uint16_t CRC16_TABLE[256] = {
    0x0000, 0x1021, 0x2042, 0x3063, 0x4084, 0x50A5, 0x60C6, 0x70E7,
    0x8108, 0x9129, 0xA14A, 0xB16B, 0xC18C, 0xD1AD, 0xE1CE, 0xF1EF,
    0x1231, 0x0210, 0x3273, 0x2252, 0x52B5, 0x4294, 0x72F7, 0x62D6,
    0x322C, 0x220D, 0x126E, 0x024F, 0x72A5, 0x6284, 0x52E7, 0x42C6,
    0x2462, 0x3443, 0x0420, 0x1401, 0x64E6, 0x74C7, 0x44A4, 0x5485,
    0x3653, 0x2672, 0x1611, 0x0630, 0x76D7, 0x66F6, 0x5695, 0x46B4,
    0x48C3, 0x58E2, 0x6881, 0x78A0, 0x0847, 0x1866, 0x2805, 0x3824,
    0x5AF2, 0x4AD3, 0x7AB0, 0x6A91, 0x1A76, 0x0A57, 0x3A34, 0x2A15,
    0x9186, 0x81A7, 0xB1E4, 0xA1C5, 0xD102, 0xC123, 0xF160, 0xE141,
    0x8397, 0x93B6, 0xA3D5, 0xB3F4, 0xC333, 0xD312, 0xE371, 0xF350,
    0xF56F, 0xE54E, 0xD52D, 0xC50C, 0xB5EB, 0xA5CA, 0x95A9, 0x8588,
    0xF72E, 0xE70F, 0xD76C, 0xC74D, 0xB7AA, 0xA78B, 0x97E8, 0x87C9,
    0xD9BE, 0xC99F, 0xF9FC, 0xE9DD, 0x993A, 0x891B, 0xB978, 0xA959,
    0xDBDF, 0xCBFE, 0xFB9D, 0xEBBC, 0x9B5B, 0x8B7A, 0xBB19, 0xAB38,
    0xA10D, 0xB12C, 0x814F, 0x916E, 0xE1A9, 0xF188, 0xC1EB, 0xD1CA,
    0xA36C, 0xB34D, 0x832E, 0x930F, 0xE3E8, 0xF3C9, 0xC3AA, 0xD38B,
    0xCDE4, 0xDDC5, 0xEDA6, 0xFD87, 0x8D60, 0x9D41, 0xAD22, 0xBD03,
    0xCF05, 0xDF24, 0xEF47, 0xFF66, 0x8F81, 0x9FA0, 0xAFC3, 0xBFE2,
    0xC595, 0xD5B4, 0xE5D7, 0xF5F6, 0x8511, 0x9530, 0xA553, 0xB572,
    0xC7D4, 0xD7F5, 0xE796, 0xF7B7, 0x8750, 0x9771, 0xA712, 0xB733,
    0x6984, 0x79A5, 0x49C6, 0x59E7, 0x2900, 0x3921, 0x0942, 0x1963,
    0x7BC5, 0x6BE4, 0x5B87, 0x4BA6, 0x3B41, 0x2B60, 0x1B03, 0x0B22,
    0x79D6, 0x69F7, 0x5994, 0x49B5, 0x3952, 0x2973, 0x1910, 0x0931,
    0x7BE7, 0x6BC6, 0x5BA5, 0x4B84, 0x3B63, 0x2B42, 0x1B21, 0x0B00,
    0x61DD, 0x71FC, 0x419F, 0x51BE, 0x2159, 0x3178, 0x011B, 0x113A,
    0x63BC, 0x739D, 0x43FE, 0x53DF, 0x2338, 0x3319, 0x037A, 0x135B,
    0x51F5, 0x41D4, 0x71B7, 0x6196, 0x1171, 0x0150, 0x3133, 0x2112,
    0x53B4, 0x4395, 0x73F6, 0x63D7, 0x1330, 0x0311, 0x3372, 0x2353,
    0x598E, 0x49AF, 0x79CC, 0x69ED, 0x190A, 0x092B, 0x3948, 0x2969,
    0x5BCF, 0x4BEE, 0x7B8D, 0x6BAC, 0x1B4B, 0x0B6A, 0x3B09, 0x2B28,
    0x49A1, 0x5980, 0x69E3, 0x79C2, 0x0925, 0x1904, 0x2967, 0x3946,
    0x4BE0, 0x5BC1, 0x6BA2, 0x7B83, 0x0B64, 0x1B45, 0x2B26, 0x3B07,
};

uint16_t frag_crc16(const uint8_t *data, uint8_t len)
{
    uint16_t crc = 0xFFFF;
    for (uint8_t i = 0; i < len; i++) {
        crc = (crc << 8) ^ CRC16_TABLE[((crc >> 8) ^ data[i]) & 0xFF];
    }
    return crc;
}

void frag_reassembler_init(frag_reassembler_t *ra, uint16_t block_id,
                           uint8_t original_count, uint8_t frag_size,
                           uint8_t *assembly_buf, uint32_t assembly_size)
{
    memset(ra, 0, sizeof(*ra));
    ra->block_id = block_id;
    ra->original_count = original_count;
    ra->frag_size = frag_size;
    ra->assembly_buf = assembly_buf;
    ra->assembly_size = assembly_size;
    memset(ra->received_map, 0, sizeof(ra->received_map));
}

int frag_reassembler_feed(frag_reassembler_t *ra, const uint8_t *frame, uint16_t frame_len)
{
    if (frame_len < FRAG_HEADER_SIZE) return -1;

    frag_header_t hdr;
    memcpy(&hdr, frame, FRAG_HEADER_SIZE);

    if (hdr.block_id != ra->block_id) return -2;
    if (hdr.original_count != ra->original_count) return -3;

    uint16_t payload_len = frame_len - FRAG_HEADER_SIZE;
    if (payload_len != ra->frag_size && hdr.frag_index < hdr.original_count - 1) return -4;

    if (hdr.frag_index >= ra->original_count + 32) return -5;

    uint8_t byte_idx = hdr.frag_index / 8;
    uint8_t bit_idx = hdr.frag_index % 8;
    if (ra->received_map[byte_idx] & (1 << bit_idx)) return 1;

    ra->received_map[byte_idx] |= (1 << bit_idx);

    uint32_t offset = (uint32_t)hdr.frag_index * ra->frag_size;
    if (offset + payload_len > ra->assembly_size) return -6;
    memcpy(ra->assembly_buf + offset, frame + FRAG_HEADER_SIZE, payload_len);

    ra->frags_received++;

    if (ra->frags_received >= ra->original_count) {
        ra->complete = true;
        return 0;
    }

    return 1;
}

uint16_t frag_make_frame(uint16_t block_id, uint8_t frag_index, uint8_t original_count,
                         const uint8_t *payload, uint8_t payload_len,
                         uint8_t *out, uint16_t out_size)
{
    if (out_size < FRAG_HEADER_SIZE + payload_len) return 0;

    frag_header_t hdr;
    hdr.block_id = block_id;
    hdr.frag_index = frag_index;
    hdr.original_count = original_count;
    hdr.crc16 = 0;

    memcpy(out, &hdr, FRAG_HEADER_SIZE);
    memcpy(out + FRAG_HEADER_SIZE, payload, payload_len);

    hdr.crc16 = frag_crc16(out, FRAG_HEADER_SIZE + payload_len);
    memcpy(out, &hdr, FRAG_HEADER_SIZE);

    return FRAG_HEADER_SIZE + payload_len;
}
